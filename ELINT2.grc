options:
  parameters:
    author: Lupu Daniel
    generate_options: qt_gui
    id: ELINT2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1e6
    low_cutoff_freq: 100e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 200e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 1e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: ccc
  states: {}

connections:
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
