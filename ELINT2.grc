options:
  parameters:
    author: Lupu Daniel
    generate_options: qt_gui
    id: ELINT2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1e6
    low_cutoff_freq: 100e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 200e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TICK")
    period: '10000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, start=1e6, stop=5.5e6, step=100e3):
              gr.basic_block.__init__(self, name="Freq Sweeper", in_sig=None, out_sig=None)
              self.start = start
              self.stop = stop
              self.step = step
              self.freq = self.start
              self.running = True
              self.message_port_register_in(pmt.intern("cmd"))
              self.set_msg_handler(pmt.intern("cmd"), self.handle_cmd)
          
          def handle_cmd(self, msg):
              # DEBUG: print the type and contents of the message
              print("Freq Sweeper got msg:", msg, "type:", type(msg))
              # Accept both strings and PMT symbols and floats for debugging
              if pmt.is_symbol(msg):
                  m = pmt.symbol_to_string(msg)
              elif pmt.is_string(msg):
                  m = pmt.symbol_to_string(msg)
              elif isinstance(msg, str):
                  m = msg
              elif pmt.is_number(msg):
                  # Ignore floats, but print for debug
                  print("Ignored float message:", msg)
                  return
              else:
                  m = str(msg)

              if m == "TICK" and self.running:
                  self.freq += self.step
                  if self.freq > self.stop:
                      self.freq = self.start
                  try:
                      self.set_variable("freq", self.freq)
                      print("Set freq to", self.freq)
                  except Exception as e:
                      print("Freq update error:", e)
              elif m == "START":
                  self.running = True
                  print("Freq Sweeper: started")
              elif m == "STOP":
                  self.running = False
                  print("Freq Sweeper: stopped")
              else:
                  print("Freq Sweeper: Unknown message", m)
    start: 1e6
    step: 100e6
    stop: 5.5e9
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: 2e6
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: ccc
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: STOP
    msgName: pressed
    relBackgroundColor: black
    relFontColor: red
    type: string
    value: STOP
  states: {}
- name: variable_qtgui_msg_push_button_1
  id: variable_qtgui_msg_push_button
  parameters:
    label: START
    msgName: pressed
    relBackgroundColor: black
    relFontColor: green
    type: string
    value: START
  states: {}

connections:
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, cmd]
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, epy_block_0, cmd]
- [variable_qtgui_msg_push_button_1, pressed, epy_block_0, cmd]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
